# Keil uVision project flaskmemory_new_startover_code.uvprojx, settings and files
target flaskmemory_new_startover_code (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F207VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: flaskmemory_new_startover_code +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F207xx
  c include: ../Core/Inc;  ../Drivers/STM32F2xx_HAL_Driver/Inc;  ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F2xx/Include;  ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f2xx_it.c stm32f2xx_hal_msp.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f2xx.c
software components: CMSIS:CORE 4.3.0
